# Repository larsth/rmsg_kicad_raspberry_pi_power_supply

File README.md:

# rmsg_kicad_raspberry_pi_power_supply
RMSg.dk - KiCAD, Raspberry Pi Switch Mode Power Supply

## KiCad design schematics/5volt_psu_schematic/rmsg_rpi_psu_5v3a_module/rmsg_rpi_psu_5v3a_module.kicad_pcb

Parts:
C1, C4: 100nF; C1
C2: 100uF,63V.,low-ESR; capacitor_panasonic_fr_a_100uf
C3: 1000uF,25V.,low-ESR; capacitor_multicomp_GPR_1000uF
C5: 100uF,25V.,low-ESR; capacitor_panasonic_fr_a_100uf
D1, D2, D3, D4, D7: SB560; do201-15-DO201-15
D5: RED; led5mm-LED5MM
D6: 8V7, Zener; DO-35
D8: YELLOW; led5mm-LED5MM
D9: GREEN; led5mm-LED5MM
DRILL_HOLE1, DRILL_HOLE2, DRILL_HOLE3, DRILL_HOLE4: M2_5_DRILL_HOLE; M2_50mm-Drill_hole_M2_85mm
F1, F2: T.2.5A.; fuse_holder_5mm_x_20mm_schurter
IC1: LM2576TV-ADJG; LM2576_TO-220-5_NDH0005D_HEATSINK
L1: 100uH,>=3.6A.,toroid; inductor_toroid-bourns_pm2120
L2: 22uH,>=3.6A.,toroid; inductor_toroid-bourns_pm2120
P1: CONN_2; TE_Connectivity_AMP_350209-1
P2, P3, P4, P5: MOLEX_15-24-4449; MOLEX-15-24-4449
Q1: BC547; to92-TO92
R1, R3: 20K; resistor_250milliwatt-TE_Connectivity_LR0204
R2: 10K; resistor_250milliwatt-TE_Connectivity_LR0204
R4: 1K8,>=1_W.; R7
R5: 2K87;0.1%; resistor_250milliwatt-TE_Connectivity_LR0204
R6: 1K;0.1%; resistor_250milliwatt-TE_Connectivity_LR0204
R7, R9: 270R; resistor_250milliwatt-TE_Connectivity_LR0204
R8: 196R;0.1%; resistor_250milliwatt-TE_Connectivity_LR0204

Connections:
+5V: C5.1, L2.2, P2.4 (+5V), P3.4 (+5V), P4.4 (+5V), P5.4 (+5V), R9.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (A), D2.1 (A), D5.2 (K), D7.1 (A), D8.2 (K), D9.2 (K), IC1.3 (GND), P2.2 (GND), P2.3 (GND), P3.2 (GND), P3.3 (GND), P4.2 (GND), P4.3 (GND), P5.2 (GND), P5.3 (GND), Q1.3 (E), R2.1, R6.2
unnamed: R5.1, R8.1
unnamed: IC1.4 (FEEDBACK), R5.2, R6.1
unnamed: F1.1, P1.2 (PM)
unnamed: P2.1 (+12V), P3.1 (+12V), P4.1 (+12V), P5.1 (+12V)
unnamed: D5.1 (A), R4.1
unnamed: D1.2 (K), D3.1 (A), F1.2
unnamed: D2.2 (K), D4.1 (A), P1.1
unnamed: D6.2, R1.1
unnamed: C1.1, C2.1, D3.2 (K), D4.2 (K), IC1.1 (Vin), R1.2, R3.1, R4.2
unnamed: D6.1, Q1.2 (B), R2.2
unnamed: IC1.5 (ON_/OFF), Q1.1 (C), R3.2
unnamed: D8.1 (A), R7.1
unnamed: D9.1 (A), R9.1
unnamed: F2.1, L2.1
unnamed: D7.2 (K), IC1.2 (OUTPUT), L1.1
unnamed: C3.1, C4.1, F2.2, L1.2, R7.2, R8.2

Notes on the sheet:
Vin: 14 VDC - 36 VDC, 10 VAC(RMS) - 25 VAC(RMS)
< 2,5 A.
IC1, min. efficency: 0,77, Heatsink must remove: Normal operation: (5x2,5)x(1 - 0,77) = 2,875 Watt Short circuit: (0,4x35,6x2,5) = 35,6 Watt; where: "0,4" is extra reduced duty cycle, "2,5" is 2,5 ampere, and "35,6" is maximum input voltage after Graetz bridge.
UNDERVOLTAGE LOCKOUT CIRCUIT
RIPPLE FILTER
Drill holes

Board: 2 copper layers, 100.0 x 100.0 mm, 38 parts (2 on the bottom side), 18 nets.

File schematics/5volt_psu_schematic/rmsg_rpi_psu_5v3a_module/bom-rmsg_rpi_psu_5v3a_module-by_grouped_ref.csv:

ref	value	Item count
C1	100nF	1
C2	100uF,63V.,low-ESR	1
C3	1000uF,25V.,low-ESR	1
C4	100nF	1
C5	100uF,25V.,low-ESR	1
D1..D4	SB560	4
D5	RED	1
D6	8V7, Zener	1
D7	SB560	1
D8	YELLOW	1
D9	GREEN	1
DRILL_HOLE1..DRILL_HOLE4	M2_5_DRILL_HOLE	4
F1,F2	T.2.5A.	2
IC1	LM2576TV-ADJG	1
L1	100uH,>=3.6A.,toroid	1
L2	22uH,>=3.6A.,toroid	1
P1	CONN_2	1
P2..P5	MOLEX_15-24-4449	4
Q1	BC547	1
R1	20K	1
R2	10K	1
R3	20K	1
R4	1K8,>=1_W.	1
R5	2K87;0.1%	1
R6	1K;0.1%	1
R7	270R	1
R8	196R;0.1%	1
R9	270R	1

## Commit log

2015-03-01 Changed license to the CERN OHL 1.2, and added the schematic for the +5 volt PSU.
    * Changed license to the CERN Open Hardware License (OHL) 1.2
    * Added the schematic for the +5 volt PSU.
2015-03-01 Deleted 'schematics/5volt_psu_schematic/rmsg_rpi_psu_5v3a_module/rmsg_rpi_psu_5v3a_module.kicad_pcb'
2015-03-01 Moved ./rmsg_rpi_psu_5v3a_module ../
